## zapret/Config.in
```kconfig
choice
	prompt "Firewall support"
	default NFTABLES

	config NFTABLES
		bool "nftables"

	config IPTABLES
		bool "iptables"
endchoice
```
